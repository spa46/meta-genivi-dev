LIC_FILES_CHKSUM = "file://COPYING;md5=34197a479f637beb9e09e56893f48bc2"
SRCREV = "211e117a0590583a720c53172406f34186c543bd"

S = "${WORKDIR}/git"

require libgit2-release.inc
